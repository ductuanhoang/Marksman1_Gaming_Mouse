# IAR project Marksman1.ewp, settings and files
configuration HT32F50343 (ARM, debug)
  General.OGChipSelectEditMenu: HT32F50343 Holtek HT32F50343
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F50343; USE_MEM_HT32F50343; DRIVER_LED_TOTAL=12
  ICCARM.CCIncludePath2: ..\; ..\source\library\HT32F5xxxx_Driver\inc; ..\source\library\CMSIS\Include; ..\source\library\Device\Holtek\HT32F5xxxx\Include; ..\source\library\HT32_USBD_Library\inc; ..\source\application; ..\source\application\main; ..\source\application\mouse; ..\source\application\usb; ..\source\application\led; ..\source\application\led\led_animations; ..\source\driver; ..\source\driver\board; ..\source\driver\eeprom; ..\source\driver\led_driver\is31fl3246; ..\source\driver\mouse_sensor\pmw3360; ..\source\library; ..
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=15
  OBJCOPY.OOCOutputFile: Marksman1.hex
  ILINK.IlinkOutputFile: Marksman1.out
  ILINK.IlinkIcfFile: ..\source\linker\linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../source/application/: common.h
  group application/backlight
    ../source/application/led/: color.c color.h rgb_matrix.c rgb_matrix.h rgb_matrix_drivers.c rgb_matrix_types.h rgb_timer.c rgb_timer.h
  group application/backlight/led_animation
    ../source/application/led/led_animations/: alpha_mods_anim.h breathing_anim.h colorband_pinwheel_sat_anim.h colorband_pinwheel_val_anim.h colorband_sat_anim.h colorband_spiral_sat_anim.h colorband_spiral_val_anim.h colorband_val_anim.h cycle_all_anim.h cycle_left_right_anim.h cycle_out_in_anim.h cycle_out_in_dual_anim.h cycle_pinwheel_anim.h cycle_spiral_anim.h cycle_up_down_anim.h digital_rain_anim.h dual_beacon_anim.h gradient_left_right_anim.h gradient_up_down_anim.h jellybean_raindrops_anim.h rainbow_beacon_anim.h rainbow_moving_chevron_anim.h rainbow_pinwheels_anim.h raindrops_anim.h scanning_anim.h solid_color_anim.h solid_reactive_anim.h solid_reactive_cross.h solid_reactive_nexus.h solid_reactive_simple_anim.h solid_reactive_wide.h solid_splash_anim.h splash_anim.h typing_heatmap_anim.h
  group application/main
    ../source/application/main/: ht32f5xxxx_01_it.c ht32f5xxxx_conf.h main.c
  group application/mouse
    ../source/application/mouse/: button.c button.h button_svc.c button_svc.h led_svc.c led_svc.h mouse_data.c mouse_data.h sensor_svc.c sensor_svc.h usb_svc.c usb_svc.h
  group application/retarget
    ../source/library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group application/usb
    ../source/application/usb/: ht32_usbd_class.c ht32_usbd_class.h ht32_usbd_descriptor.c ht32_usbd_descriptor.h ht32f5xxxx_01_usbdconf.h
  group driver/board
    ../source/driver/board/: ht32_board.c ht32_board.h
  group driver/EEPROM
    ../source/driver/eeprom/: eeprom.c eeprom.h
  group driver/IS32FL3246
    ../source/driver/led_driver/is31fl3246/: is31fl3246.c is31fl3246.h
  group driver/PMW3360
    ../source/driver/mouse_sensor/pmw3360/: pmw3360.c pmw3360.h pmw3360_fw.c pmw3360_reg.h
  group library/3rd_libs
    ../source/library/lib8tion/: lib8tion.c
  group library/CMSIS
    ../source/application/main/: system_ht32f5xxxx_06.c
  group library/ht32_std_lib
    ../source/library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_div.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sled.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group library/ht32_usbd_lib
    ../source/library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group startup
    ../source/startup/: ht32_op.c startup_ht32f5xxxx_iar_06.s
